options:
  parameters:
    author: gr-linux-crypto
    category: '[gr-linux-crypto]/Examples'
    copyright: Copyright 2024
    description: FreeDV voice signing using Nitrokey + gr-nacl Ed25519. Signs Codec2 compressed voice frames before FreeDV modulation.
    generate_options: qt_gui
    id: freedv_nitrokey_signing
    output_language: python
    title: FreeDV Signing with Nitrokey
  states: {}

blocks:
- name: nitrokey_slot
  id: variable_qtgui_entry
  parameters:
    comment: Nitrokey slot number (0-15) containing Ed25519 private key
    gui_hint: 1,0,1,1
    label: Nitrokey Slot
    type: int
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Sample rate for audio processing
    value: '8000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    comment: Audio input for voice
    samp_rate: '48000'
  states: {}
- name: blocks_char_to_short_0
  id: blocks_char_to_short
  parameters:
    comment: Convert signed bytes to short for FreeDV
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Save signed FreeDV signal to file (replace with radio hardware for TX)
    file: /tmp/freedv_signed_transmission.bin
    type: short
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    comment: Convert float audio to short for Codec2
    scale: '32768'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      try:
          from gnuradio import nacl
          NACL_AVAILABLE = True
      except ImportError:
          NACL_AVAILABLE = False
          print("Warning: gr-nacl not available. Signing will not work.")

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='FreeDV Voice Signer',
                  in_sig=[np.uint8, np.uint8],
                  out_sig=[np.uint8]
              )
              self._codec2_buffer = bytearray()
              self._key_buffer = bytearray()
              self._signature_length = 64  # Ed25519 signature is 64 bytes
              
          def work(self, input_items, output_items):
              codec2_in = input_items[0]
              key_in = input_items[1]
              
              # Collect Codec2 compressed voice data
              if len(codec2_in) > 0:
                  self._codec2_buffer.extend(codec2_in.tolist())
              
              # Collect key data from Nitrokey (need 32 bytes for Ed25519)
              if len(key_in) > 0:
                  self._key_buffer.extend(key_in.tolist())
              
              out_len = min(len(output_items[0]), len(codec2_in))
              
              # Sign Codec2 frames (typically 8 bytes for 3200 bps mode)
              if len(self._codec2_buffer) >= 8 and len(self._key_buffer) >= 32:
                  try:
                      # Get Codec2 frame (8 bytes)
                      codec2_frame = bytes(self._codec2_buffer[:8])
                      self._codec2_buffer = self._codec2_buffer[8:]
                       
                      # Get private key (32 bytes for Ed25519)
                      private_key = bytes(self._key_buffer[:32])
                      
                      if NACL_AVAILABLE and len(private_key) == 32:
                          # Create Ed25519 signature using gr-nacl
                          try:
                              signature = nacl.sign_ed25519(codec2_frame, private_key)
                          except AttributeError:
                              print("Warning: gr-nacl sign_ed25519 not found. Using placeholder.")
                              signature = b'\x00' * 64
                          
                          # Append signature to Codec2 frame
                          signed_frame = codec2_frame + signature
                          
                          # Output signed frame (8 bytes Codec2 + 64 bytes signature = 72 bytes total)
                          out_data = np.frombuffer(signed_frame[:out_len], dtype=np.uint8)
                          if len(out_data) <= len(output_items[0]):
                              output_items[0][:len(out_data)] = out_data
                               return len(out_data)
                      else:
                          # No signing available, just pass Codec2 frame
                          out_data = np.frombuffer(codec2_frame[:out_len], dtype=np.uint8)
                          if len(out_data) <= len(output_items[0]):
                              output_items[0][:len(out_data)] = out_data
                               return len(out_data)
                  except Exception as e:
                      print(f"Signing error: {e}")
                      import traceback
                      traceback.print_exc()
              
              # No data to output yet
              return 0
  states: {}
- name: linux_crypto_nitrokey_interface_0
  id: linux_crypto_nitrokey_interface
  parameters:
    auto_repeat: 'False'
    comment: Load Ed25519 private key from Nitrokey slot for signing
    slot: nitrokey_slot
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    comment: Visualize FreeDV signal spectrum
    fc: '0'
    fftsize: '1024'
    label1: FreeDV Signal
    name: '"FreeDV Spectrum"'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: Resample audio to 8kHz for Codec2
    decim: '6'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: vocoder_codec2_encode_sp_0
  id: vocoder_codec2_encode_sp
  parameters:
    comment: Codec2 encoder - compresses voice to bits
    mode: codec2.MODE_2400
  states: {}
- name: vocoder_freedv_tx_ss_0
  id: vocoder_freedv_tx_ss
  parameters:
    clip_val: 'False'
    comment: FreeDV modulator - transmits signed voice
    interleave_frames: '1'
    mode: freedv_api.MODE_1600
    tx_bpf_val: 'True'
    txt_msg: Signed FreeDV
  states: {}

connections:
- [audio_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_char_to_short_0, '0', vocoder_freedv_tx_ss_0, '0']
- [blocks_float_to_short_0, '0', vocoder_codec2_encode_sp_0, '0']
- [blocks_throttle2_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [epy_block_0, '0', blocks_char_to_short_0, '0']
- [linux_crypto_nitrokey_interface_0, '0', epy_block_0, '1']
- [rational_resampler_xxx_0, '0', blocks_float_to_short_0, '0']
- [vocoder_codec2_encode_sp_0, '0', epy_block_0, '0']
- [vocoder_freedv_tx_ss_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
