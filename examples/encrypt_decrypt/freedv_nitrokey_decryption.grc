options:
  parameters:
    author: gr-linux-crypto
    category: '[gr-linux-crypto]/Examples'
    copyright: Copyright 2024
    description: FreeDV voice decryption using Nitrokey + gr-nacl ChaCha20-Poly1305. Decrypts Codec2 compressed voice data after FreeDV demodulation.
    generate_options: qt_gui
    id: freedv_nitrokey_decryption
    output_language: python
    title: FreeDV Decryption with Nitrokey
  states: {}

blocks:
- name: freedv_mode
  id: variable_qtgui_entry
  parameters:
    comment: FreeDV mode (700, 1600, 2020, etc.)
    gui_hint: 3,0,1,1
    label: FreeDV Mode
    type: string
    value: MODE_1600
  states: {}
- name: nitrokey_slot
  id: variable_qtgui_entry
  parameters:
    comment: Nitrokey slot number (0-15) containing decryption key
    gui_hint: 1,0,1,1
    label: Nitrokey Slot
    type: int
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Sample rate for audio processing
    value: '8000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: Audio output for decrypted voice
    samp_rate: '48000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: Load encrypted FreeDV signal from file
    file: /tmp/freedv_encrypted.bin
    repeat: 'False'
    type: short
  states: {}
- name: blocks_short_to_char_0
  id: blocks_short_to_char
  parameters:
    comment: Convert short to bytes for decryption
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    comment: Convert short audio to float
    scale: '32768'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      try:
          from gnuradio import nacl
          NACL_AVAILABLE = True
      except ImportError:
          NACL_AVAILABLE = False
          print("Warning: gr-nacl not available. Decryption will not work.")

      try:
          from cryptography.hazmat.primitives.ciphers.aead import ChaCha20Poly1305
          CRYPTOGRAPHY_AVAILABLE = True
      except ImportError:
          CRYPTOGRAPHY_AVAILABLE = False
          print("Warning: cryptography library not available. Using fallback.")

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='FreeDV Voice Decryptor',
                  in_sig=[np.uint8, np.uint8],
                  out_sig=[np.uint8]
              )
              self._encrypted_buffer = bytearray()
              self._key_buffer = bytearray()
              self._nonce_counter = 0
              self._nonce_length = 12  # 96 bits for ChaCha20-Poly1305
               self._frame_size_with_tag = 8 + 16  # Codec2 frame (8) + Poly1305 tag (16)
              
          def work(self, input_items, output_items):
              encrypted_in = input_items[0]
              key_in = input_items[1]
              
              # Collect encrypted Codec2 data
              if len(encrypted_in) > 0:
                  self._encrypted_buffer.extend(encrypted_in.tolist())
              
              # Collect key from Nitrokey (need 32 bytes for ChaCha20)
              if len(key_in) > 0:
                  self._key_buffer.extend(key_in.tolist())
              
              out_len = min(len(output_items[0]), len(encrypted_in))
               
              # Decrypt when we have enough data
              if len(self._encrypted_buffer) >= self._frame_size_with_tag and len(self._key_buffer) >= 32:
                  try:
                      # Get encrypted frame (Codec2 frame + auth tag)
                      encrypted_frame = bytes(self._encrypted_buffer[:self._frame_size_with_tag])
                       self._encrypted_buffer = self._encrypted_buffer[self._frame_size_with_tag:]
                      
                      # Get decryption key (32 bytes for ChaCha20)
                      key = bytes(self._key_buffer[:32])
                      
                       # Generate nonce (12 bytes, incrementing counter - must match encryption)
                      nonce = self._nonce_counter.to_bytes(self._nonce_length, byteorder='little')
                      self._nonce_counter = (self._nonce_counter + 1) % (2**96)
                      
                      # Decrypt Codec2 frame
                      if CRYPTOGRAPHY_AVAILABLE:
                          cipher = ChaCha20Poly1305(key)
                          try:
                              decrypted_frame = cipher.decrypt(nonce, encrypted_frame, None)
                          except Exception as e:
                              print(f"Decryption failed: {e}")
                              decrypted_frame = b'\x00' * 8  # Silent frame on error
                      elif NACL_AVAILABLE:
                          # Try gr-nacl if available
                          try:
                              decrypted_frame = nacl.decrypt_chacha20_poly1305(encrypted_frame, key, nonce)
                          except AttributeError:
                              decrypted_frame = encrypted_frame[:8]  # Fallback: no decryption
                      else:
                          decrypted_frame = encrypted_frame[:8]  # No decryption available
                      
                       # Output decrypted Codec2 frame
                      if len(decrypted_frame) <= len(output_items[0]):
                          out_data = np.frombuffer(decrypted_frame[:out_len], dtype=np.uint8)
                          if len(out_data) <= len(output_items[0]):
                              output_items[0][:len(out_data)] = out_data
                               return len(out_data)
                  except Exception as e:
                      print(f"Decryption error: {e}")
                      import traceback
                      traceback.print_exc()
              
              # No data to output yet
              return 0
  states: {}
- name: linux_crypto_nitrokey_interface_0
  id: linux_crypto_nitrokey_interface
  parameters:
    auto_repeat: 'False'
    comment: Load decryption key from Nitrokey slot
    slot: nitrokey_slot
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    comment: Resample audio from 8kHz to 48kHz
    decim: '1'
    interp: '6'
    taps: ''
    type: fff
  states: {}
- name: vocoder_codec2_decode_ps_0
  id: vocoder_codec2_decode_ps
  parameters:
    comment: Codec2 decoder - decompresses voice bits
    mode: codec2.MODE_2400
  states: {}
- name: vocoder_freedv_rx_ss_0
  id: vocoder_freedv_rx_ss
  parameters:
    comment: FreeDV demodulator - receives encrypted voice
    interleave_frames: '1'
    mode: freedv_api.MODE_1600
    squelch_enable: 'True'
    squelch_thresh: '-100.0'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_short_to_char_0, '0', epy_block_0, '0']
- [blocks_short_to_float_0, '0', rational_resampler_xxx_1, '0']
- [blocks_throttle2_0, '0', vocoder_freedv_rx_ss_0, '0']
- [epy_block_0, '0', vocoder_codec2_decode_ps_0, '0']
- [linux_crypto_nitrokey_interface_0, '0', epy_block_0, '1']
- [rational_resampler_xxx_1, '0', audio_sink_0, '0']
- [vocoder_codec2_decode_ps_0, '0', blocks_short_to_float_0, '0']
- [vocoder_freedv_rx_ss_0, '0', blocks_short_to_char_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
