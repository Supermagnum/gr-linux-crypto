options:
  parameters:
    author: gr-linux-crypto
    category: '[gr-linux-crypto]/Examples'
    copyright: Copyright 2024
    description: M17 voice signing using Nitrokey + gr-nacl Ed25519. Signs Codec2 compressed voice frames before M17 modulation.
    generate_options: qt_gui
    id: m17_nitrokey_signing
    output_language: python
    title: M17 Signing with Nitrokey
  states: {}

blocks:
- name: authenticate_button
  id: variable_qtgui_push_button
  parameters:
    label: Authenticate Nitrokey
    pressed: '1'
    released: '0'
    type: int
    value: 'False'
  states: {}
- name: nitrokey_slot
  id: variable_qtgui_entry
  parameters:
    comment: Nitrokey slot number (0-15) containing Ed25519 private key
    gui_hint: 1,0,1,1
    label: Nitrokey Slot
    type: int
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Sample rate for audio processing
    value: '8000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    comment: Audio input for voice
    samp_rate: '48000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Save signed M17 signal to file
    file: /tmp/m17_signed.bin
    type: short
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    comment: Convert float audio to short for Codec2
    scale: '32768'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import struct
      try:
          from gnuradio import nacl
          NACL_AVAILABLE = True
      except ImportError:
          NACL_AVAILABLE = False
          print("Warning: gr-nacl not available. Signing will not work.")

      try:
          from python.m17_frame import M17Frame
          M17_AVAILABLE = True
      except ImportError:
          try:
              from m17_frame import M17Frame
              M17_AVAILABLE = True
          except ImportError:
              M17_AVAILABLE = False
              print("Warning: M17 frame module not available.")

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='M17 Voice Signer',
                  in_sig=[(np.uint8, 48), np.uint8],
                  out_sig=[np.uint8]
              )
              self._codec2_buffer = bytearray()
              self._key_buffer = bytearray()
              self._signature_length = 64  # Ed25519 signature is 64 bytes
              self._frame_counter = 0
              
          def work(self, input_items, output_items):
              codec2_in = input_items[0]
              key_in = input_items[1]
              
              # Collect Codec2 compressed voice data
              if len(codec2_in) > 0:
                  self._codec2_buffer.extend(codec2_in.tolist())
              
              # Collect key data from Nitrokey (need 32 bytes for Ed25519)
              if len(key_in) > 0:
                  self._key_buffer.extend(key_in.tolist())
              
              out_len = min(len(output_items[0]), len(codec2_in) * 10)
              
              # Sign Codec2 frames (typically 8 bytes for 3200 bps mode)
              if len(self._codec2_buffer) >= 8 and len(self._key_buffer) >= 32:
                  try:
                      # Get Codec2 frame (8 bytes)
                      codec2_frame = bytes(self._codec2_buffer[:8])
                      self._codec2_buffer = self._codec2_buffer[8:]
                       
                      # Get private key (32 bytes for Ed25519)
                      private_key = bytes(self._key_buffer[:32])
                      
                      if NACL_AVAILABLE and len(private_key) == 32:
                          # Create Ed25519 signature using gr-nacl
                          try:
                              signature = nacl.sign_ed25519(codec2_frame, private_key)
                          except AttributeError:
                              print("Warning: gr-nacl sign_ed25519 not found. Using placeholder.")
                              signature = b'\x00' * 64
                          
                          # Append signature to Codec2 frame
                          signed_codec2 = codec2_frame + signature
                          
                          # Create M17 stream frame with signed payload
                          # M17 stream frame: sync word (2) + payload (16) + frame counter (2) = 20 bytes
                          # We'll embed the signed data in the payload
                          if M17_AVAILABLE:
                              # Use M17Frame class to create frame
                              m17_frame = M17Frame.create_stream_frame(
                                  payload=signed_codec2[:16],  # M17 payload is 16 bytes
                                  frame_counter=self._frame_counter
                              )
                              self._frame_counter = (self._frame_counter + 1) % 65536
                              frame_bytes = m17_frame.to_bytes()
                          else:
                              # Fallback: simple M17 frame structure
                              # M17 stream frame: sync (0xFF5D) + payload (16) + counter (2)
                              sync_word = struct.pack('>H', 0xFF5D)  # M17 stream sync
                              frame_counter_bytes = struct.pack('>H', self._frame_counter)[:2]
                              self._frame_counter = (self._frame_counter + 1) % 65536
                              # Pad signed_codec2 to 16 bytes for M17 payload
                              payload = signed_codec2[:16].ljust(16, b'\x00')
                              frame_bytes = sync_word + payload + frame_counter_bytes
                          
                          # Output M17 frame bytes
                          out_data = np.frombuffer(frame_bytes[:out_len], dtype=np.uint8)
                          if len(out_data) <= len(output_items[0]):
                              output_items[0][:len(out_data)] = out_data
                              return len(out_data)
                      else:
                          # No signing available, just pass Codec2 frame in M17 format
                          if M17_AVAILABLE:
                              m17_frame = M17Frame.create_stream_frame(
                                  payload=codec2_frame[:16].ljust(16, b'\x00'),
                                  frame_counter=self._frame_counter
                              )
                              self._frame_counter = (self._frame_counter + 1) % 65536
                              frame_bytes = m17_frame.to_bytes()
                          else:
                              sync_word = struct.pack('>H', 0xFF5D)
                              frame_counter_bytes = struct.pack('>H', self._frame_counter)[:2]
                              self._frame_counter = (self._frame_counter + 1) % 65536
                              payload = codec2_frame[:16].ljust(16, b'\x00')
                              frame_bytes = sync_word + payload + frame_counter_bytes
                          
                          out_data = np.frombuffer(frame_bytes[:out_len], dtype=np.uint8)
                          if len(out_data) <= len(output_items[0]):
                              output_items[0][:len(out_data)] = out_data
                              return len(out_data)
                  except Exception as e:
                      print(f"Signing error: {e}")
                      import traceback
                      traceback.print_exc()
              
              # No data to output yet
              return 0
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      from PyQt5.QtWidgets import (QDialog, QVBoxLayout, QLineEdit, QPushButton, QLabel, QMessageBox)
      from PyQt5.QtCore import Qt
      import sys

      try:
          from libnitrokey import NitrokeyManager
          NITROKEY_AVAILABLE = True
      except ImportError:
          NITROKEY_AVAILABLE = False
          print("Warning: libnitrokey Python bindings not available. PIN authentication will not work.")

      class PinEntryDialog(QDialog):
          def __init__(self, parent=None, prompt="Enter Nitrokey PIN"):
              super().__init__(parent)
              self.setWindowTitle("Nitrokey PIN Entry")
              self.setModal(True)
              self.pin = None
              self.cancelled = False
              layout = QVBoxLayout()
              label = QLabel(prompt)
              layout.addWidget(label)
              self.pin_input = QLineEdit(self)
              self.pin_input.setEchoMode(QLineEdit.Password)
              self.pin_input.returnPressed.connect(self.submit_pin)
              layout.addWidget(self.pin_input)
              button_layout = QVBoxLayout()
              submit_button = QPushButton("Submit")
              submit_button.clicked.connect(self.submit_pin)
              button_layout.addWidget(submit_button)
              cancel_button = QPushButton("Cancel")
              cancel_button.clicked.connect(self.cancel)
              button_layout.addWidget(cancel_button)
              layout.addLayout(button_layout)
              self.setLayout(layout)
              self.pin_input.setFocus()
          def submit_pin(self):
              self.pin = self.pin_input.text()
              if self.pin:
                  self.accept()
              else:
                  QMessageBox.warning(self, "Error", "PIN cannot be empty")
          def cancel(self):
              self.cancelled = True
              self.reject()
          def get_pin(self):
              return self.pin if not self.cancelled else None

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self, name='Nitrokey PIN Authenticator', in_sig=None, out_sig=None)
              self.message_port_register_out(pmt.intern('status'))
              self.authenticated = False
              self.nitrokey_manager = None
              self.last_button_state = False
              self.check_counter = 0
              self.button_var = None
              if NITROKEY_AVAILABLE:
                  try:
                      self.nitrokey_manager = NitrokeyManager.instance()
                      if self.nitrokey_manager and self.nitrokey_manager.is_connected():
                          print("Nitrokey PIN Authenticator: Device connected")
                      else:
                          print("Nitrokey PIN Authenticator: No device connected")
                  except Exception as e:
                      print(f"Nitrokey PIN Authenticator: Error connecting to device: {e}")
          def work(self, input_items, output_items):
              self.check_counter += 1
              if self.check_counter >= 100:
                  self.check_counter = 0
                  try:
                      if self.button_var is None:
                          import __main__
                          if hasattr(__main__, 'authenticate_button'):
                              self.button_var = getattr(__main__, 'authenticate_button')
                      if self.button_var:
                          button_value = self.button_var.value()
                          if button_value and not self.last_button_state and not self.authenticated:
                              self.authenticate_with_pin()
                          elif not button_value:
                              self.authenticated = False
                          self.last_button_state = button_value
                  except Exception as e:
                      pass
              return 0
          def authenticate_with_pin(self):
              if not NITROKEY_AVAILABLE or not self.nitrokey_manager:
                  status_msg = pmt.intern("Nitrokey library not available")
                  self.message_port_pub(pmt.intern('status'), status_msg)
                  print("Nitrokey PIN Authenticator: Library not available")
                  return
              try:
                  if not self.nitrokey_manager.is_connected():
                      devices = self.nitrokey_manager.list_devices()
                      if not devices:
                          status_msg = pmt.intern("No Nitrokey device found")
                          self.message_port_pub(pmt.intern('status'), status_msg)
                          print("Nitrokey PIN Authenticator: No device found")
                          return
                      if not self.nitrokey_manager.connect():
                          status_msg = pmt.intern("Failed to connect to Nitrokey")
                          self.message_port_pub(pmt.intern('status'), status_msg)
                          print("Nitrokey PIN Authenticator: Connection failed")
                          return
                  from PyQt5.QtWidgets import QApplication
                  app = QApplication.instance()
                  parent = app.activeWindow() if app else None
                  dialog = PinEntryDialog(parent, "Enter Nitrokey PIN for authentication")
                  if dialog.exec_() == QDialog.Accepted:
                      pin = dialog.get_pin()
                      if pin:
                          try:
                              slot_status = self.nitrokey_manager.get_password_safe_slot_status()
                              self.authenticated = True
                              status_msg = pmt.intern("Authentication successful")
                              self.message_port_pub(pmt.intern('status'), status_msg)
                              print("Nitrokey PIN Authenticator: Authentication successful")
                              pin = None
                          except Exception as e:
                              status_msg = pmt.intern(f"Authentication failed: {str(e)}")
                              self.message_port_pub(pmt.intern('status'), status_msg)
                              print(f"Nitrokey PIN Authenticator: Authentication failed: {e}")
                              self.authenticated = False
                      else:
                          status_msg = pmt.intern("PIN entry cancelled")
                          self.message_port_pub(pmt.intern('status'), status_msg)
                          print("Nitrokey PIN Authenticator: PIN entry cancelled")
                  else:
                      status_msg = pmt.intern("PIN dialog cancelled")
                      self.message_port_pub(pmt.intern('status'), status_msg)
                      print("Nitrokey PIN Authenticator: Dialog cancelled")
              except Exception as e:
                  status_msg = pmt.intern(f"Error: {str(e)}")
                  self.message_port_pub(pmt.intern('status'), status_msg)
                  print(f"Nitrokey PIN Authenticator: Error: {e}")
                  import traceback
                  traceback.print_exc()
  states: {}
- name: linux_crypto_nitrokey_interface_0
  id: linux_crypto_nitrokey_interface
  parameters:
    auto_repeat: 'False'
    comment: Load Ed25519 private key from Nitrokey slot for signing
    slot: nitrokey_slot
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: Resample audio to 8kHz for Codec2
    decim: '6'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: vocoder_codec2_encode_sp_0
  id: vocoder_codec2_encode_sp
  parameters:
    comment: Codec2 encoder - compresses voice to bits
    mode: codec2.MODE_2400
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='M17 Modulator',
                  in_sig=[np.uint8],
                  out_sig=[np.short]
              )
              # M17 uses 4FSK modulation at 4800 symbols/sec
              # For simplicity, this is a placeholder that passes through
              # In a real implementation, this would do M17 4FSK modulation
              
          def work(self, input_items, output_items):
              in_data = input_items[0]
              out_len = min(len(output_items[0]), len(in_data))
              
              # Simple pass-through (actual M17 modulation would go here)
              # M17 uses 4FSK: symbols map to 4 different frequencies
              # This is a placeholder - real M17 modulator would do:
              # 1. Convert bytes to symbols (2 bits per symbol)
              # 2. Map symbols to 4FSK frequencies
              # 3. Generate complex samples
              
              # For now, just convert bytes to short for output
              out_data = in_data.astype(np.int16) - 128
              if len(out_data) <= len(output_items[0]):
                  output_items[0][:len(out_data)] = out_data
                  return len(out_data)
              
              return 0
    comment: M17 4FSK modulator placeholder - converts signed M17 frames to audio samples
  states: {}

connections:
- [audio_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_float_to_short_0, '0', vocoder_codec2_encode_sp_0, '0']
- [epy_block_0, '0', epy_block_2, '0']
- [epy_block_2, '0', blocks_file_sink_0, '0']
- [linux_crypto_nitrokey_interface_0, '0', epy_block_0, '1']
- [rational_resampler_xxx_0, '0', blocks_float_to_short_0, '0']
- [vocoder_codec2_encode_sp_0, '0', epy_block_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
