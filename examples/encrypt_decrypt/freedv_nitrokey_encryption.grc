options:
  parameters:
    author: gr-linux-crypto
    category: '[gr-linux-crypto]/Examples'
    copyright: Copyright 2024
    description: FreeDV voice encryption using Nitrokey + gr-nacl ChaCha20-Poly1305. Encrypts Codec2 compressed voice data before FreeDV modulation.
    generate_options: qt_gui
    id: freedv_nitrokey_encryption
    output_language: python
    title: FreeDV Encryption with Nitrokey
  states: {}

blocks:
- name: freedv_mode
  id: variable_qtgui_entry
  parameters:
    comment: FreeDV mode (700, 1600, 2020, etc.)
    gui_hint: 3,0,1,1
    label: FreeDV Mode
    type: string
    value: MODE_1600
  states: {}
- name: nitrokey_slot
  id: variable_qtgui_entry
  parameters:
    comment: Nitrokey slot number (0-15) containing encryption key
    gui_hint: 1,0,1,1
    label: Nitrokey Slot
    type: int
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Sample rate for audio processing
    value: '8000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    comment: Audio input for voice
    samp_rate: '48000'
  states: {}
- name: blocks_char_to_short_0
  id: blocks_char_to_short
  parameters:
    comment: Convert encrypted bytes to short for FreeDV
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Save encrypted FreeDV signal to file
    file: /tmp/freedv_encrypted.bin
    type: short
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    comment: Convert float audio to short for Codec2
    scale: '32768'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      try:
          from gnuradio import nacl
          NACL_AVAILABLE = True
      except ImportError:
          NACL_AVAILABLE = False
          print("Warning: gr-nacl not available. Encryption will not work.")

      try:
          from cryptography.hazmat.primitives.ciphers.aead import ChaCha20Poly1305
          CRYPTOGRAPHY_AVAILABLE = True
      except ImportError:
          CRYPTOGRAPHY_AVAILABLE = False
          print("Warning: cryptography library not available. Using fallback.")

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='FreeDV Voice Encryptor',
                  in_sig=[np.uint8, np.uint8],
                  out_sig=[np.uint8]
              )
              self._codec2_buffer = bytearray()
              self._key_buffer = bytearray()
              self._nonce_counter = 0
              self._nonce_length = 12  # 96 bits for ChaCha20-Poly1305
              
          def work(self, input_items, output_items):
              codec2_in = input_items[0]
              key_in = input_items[1]
              
              # Collect Codec2 compressed voice data
              if len(codec2_in) > 0:
                  self._codec2_buffer.extend(codec2_in.tolist())
              
              # Collect key from Nitrokey (need 32 bytes for ChaCha20)
              if len(key_in) > 0:
                  self._key_buffer.extend(key_in.tolist())
              
              out_len = min(len(output_items[0]), len(codec2_in))
              
              # Encrypt when we have enough data
              if len(self._codec2_buffer) >= 8 and len(self._key_buffer) >= 32:
                  try:
                      # Get Codec2 frame (typically 8 bytes for 3200 bps mode)
                      frame_size = min(8, len(self._codec2_buffer))
                      codec2_frame = bytes(self._codec2_buffer[:frame_size])
                       self._codec2_buffer = self._codec2_buffer[frame_size:]
                      
                      # Get encryption key (32 bytes for ChaCha20)
                      key = bytes(self._key_buffer[:32])
                      
                      # Generate nonce (12 bytes, incrementing counter)
                      nonce = self._nonce_counter.to_bytes(self._nonce_length, byteorder='little')
                      self._nonce_counter = (self._nonce_counter + 1) % (2**96)
                      
                      # Encrypt Codec2 frame
                      if CRYPTOGRAPHY_AVAILABLE:
                          cipher = ChaCha20Poly1305(key)
                          encrypted_frame = cipher.encrypt(nonce, codec2_frame, None)
                      elif NACL_AVAILABLE:
                          # Try gr-nacl if available
                          try:
                              encrypted_frame = nacl.encrypt_chacha20_poly1305(codec2_frame, key, nonce)
                          except AttributeError:
                              encrypted_frame = codec2_frame  # Fallback: no encryption
                      else:
                           encrypted_frame = codec2_frame  # No encryption available
                      
                      # Output encrypted frame
                      if len(encrypted_frame) <= len(output_items[0]):
                          out_data = np.frombuffer(encrypted_frame[:out_len], dtype=np.uint8)
                          if len(out_data) <= len(output_items[0]):
                              output_items[0][:len(out_data)] = out_data
                               return len(out_data)
                  except Exception as e:
                      print(f"Encryption error: {e}")
                      import traceback
                      traceback.print_exc()
              
              # No data to output yet
              return 0
  states: {}
- name: linux_crypto_nitrokey_interface_0
  id: linux_crypto_nitrokey_interface
  parameters:
    auto_repeat: 'False'
    comment: Load encryption key from Nitrokey slot
    slot: nitrokey_slot
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    comment: Visualize FreeDV signal spectrum
    fc: '0'
    fftsize: '1024'
    label1: FreeDV Signal
    name: '"FreeDV Spectrum"'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: Resample audio to 8kHz for Codec2
    decim: '6'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: vocoder_codec2_encode_sp_0
  id: vocoder_codec2_encode_sp
  parameters:
    comment: Codec2 encoder - compresses voice to bits
    mode: codec2.MODE_2400
  states: {}
- name: vocoder_freedv_tx_ss_0
  id: vocoder_freedv_tx_ss
  parameters:
    clip_val: 'False'
    comment: FreeDV modulator - transmits encrypted voice
    interleave_frames: '1'
    mode: freedv_api.MODE_1600
    tx_bpf_val: 'True'
    txt_msg: Encrypted FreeDV
  states: {}

connections:
- [audio_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_char_to_short_0, '0', vocoder_freedv_tx_ss_0, '0']
- [blocks_float_to_short_0, '0', vocoder_codec2_encode_sp_0, '0']
- [epy_block_0, '0', blocks_char_to_short_0, '0']
- [linux_crypto_nitrokey_interface_0, '0', epy_block_0, '1']
- [rational_resampler_xxx_0, '0', blocks_float_to_short_0, '0']
- [vocoder_codec2_encode_sp_0, '0', epy_block_0, '0']
- [vocoder_freedv_tx_ss_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
