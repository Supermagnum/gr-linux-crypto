options:
  parameters:
    author: gr-linux-crypto
    category: '[gr-linux-crypto]/Examples'
    copyright: Copyright 2024
    description: MFSK transmission with Nitrokey + gr-nacl Ed25519 signing. Signs the data before MFSK modulation.
    generate_options: qt_gui
    id: mfsk_nitrokey_signing
    output_language: python
    title: MFSK Transmission with Nitrokey Signing
  states: {}

blocks:
- name: message_text
  id: variable_qtgui_entry
  parameters:
    comment: Message to transmit (will be signed before MFSK modulation)
    gui_hint: 2,0,1,1
    label: Message to Transmit
    type: string
    value: Hello MFSK! This message is signed with Nitrokey.
  states: {}
- name: mfsk_bits_per_symbol
  id: variable
  parameters:
    comment: Bits per symbol (2 = 4-FSK, 3 = 8-FSK, 4 = 16-FSK)
    value: '2'
  states: {}
- name: nitrokey_slot
  id: variable_qtgui_entry
  parameters:
    comment: Nitrokey slot number (0-15) containing Ed25519 private key
    gui_hint: 1,0,1,1
    label: Nitrokey Slot
    type: int
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Sample rate for MFSK modulation
    value: '48000'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    comment: Symbol rate for MFSK
    value: '2400'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    comment: MFSK modulator - frequency shifts based on symbol values
    sensitivity: 2 * 3.14159 * symbol_rate / samp_rate
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Save MFSK modulated signal to file (can be transmitted or analyzed)
    file: /tmp/mfsk_signed_transmission.bin
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: '[ord(c) for c in message_text]'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: Convert signed message bytes to symbols for MFSK modulation
    dimension: '2'
    in_type: int
    out_type: complex
    symbol_table: '[i for i in range(2**mfsk_bits_per_symbol)]'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      try:
          from gnuradio import nacl
          NACL_AVAILABLE = True
      except ImportError:
          NACL_AVAILABLE = False
          print("Warning: gr-nacl not available. Signing will not work.")

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Nitrokey gr-nacl MFSK Signer',
                  in_sig=[np.uint8, np.uint8],
                  out_sig=[np.uint8]
              )
              self._message_buffer = bytearray()
              self._key_buffer = bytearray()
              self._signature_length = 64  # Ed25519 signature is 64 bytes
              self._signed = False
              
          def work(self, input_items, output_items):
              msg_in = input_items[0]
              key_in = input_items[1]
              
              # Collect message data
              if len(msg_in) > 0:
                  self._message_buffer.extend(msg_in.tolist())
              
              # Collect key data from Nitrokey (need 32 bytes for Ed25519)
              if len(key_in) > 0:
                  self._key_buffer.extend(key_in.tolist())
              
              out_len = min(len(output_items[0]), len(msg_in))
              
              # If we have complete message and key, sign it once
              if not self._signed and len(self._message_buffer) > 0 and len(self._key_buffer) >= 32:
                  try:
                      message = bytes(self._message_buffer)
                      private_key = bytes(self._key_buffer[:32])
                      
                      if NACL_AVAILABLE and len(private_key) == 32:
                          # Create Ed25519 signature using gr-nacl
                          # Note: Adjust gr-nacl API call based on actual module API
                          try:
                              signature = nacl.sign_ed25519(message, private_key)
                          except AttributeError:
                              # Fallback if API is different
                              print("Warning: gr-nacl sign_ed25519 not found. Using placeholder.")
                              signature = b'\x00' * 64
                          
                          # Append signature to message
                          signed_message = message + signature
                          
                          # Store signed message for output
                          self._signed_message = signed_message
                          self._signed = True
                          print(f"Message signed: {len(message)} bytes + {len(signature)} byte signature = {len(signed_message)} bytes total")
                      else:
                          # No signing available, just pass message
                          self._signed_message = message
                          self._signed = True
                          print("Warning: Signing not available, transmitting unsigned message")
                  except Exception as e:
                      print(f"Signing error: {e}")
                      self._signed_message = bytes(self._message_buffer)
                      self._signed = True
              
              # Output signed message
              if self._signed:
                  if len(self._signed_message) > 0:
                      out_data = np.frombuffer(self._signed_message[:out_len], dtype=np.uint8)
                      if len(out_data) <= len(output_items[0]):
                          output_items[0][:len(out_data)] = out_data
                          # Remove sent data from buffer
                          self._signed_message = self._signed_message[len(out_data):]
                          return len(out_data)
              
              # No data to output yet
              return 0
  states: {}
- name: linux_crypto_nitrokey_interface_0
  id: linux_crypto_nitrokey_interface
  parameters:
    auto_repeat: 'False'
    comment: Load Ed25519 private key from Nitrokey slot for signing
    slot: nitrokey_slot
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    comment: Visualize MFSK modulated signal spectrum
    fc: '0'
    fftsize: '1024'
    label1: MFSK Signal
    name: '"MFSK Spectrum"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: Visualize signed message data (before modulation)
    label1: Signed Message
    label2: ''
    name: '"Signed Message"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', epy_block_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', analog_frequency_modulator_fc_0, '0']
- [epy_block_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']
- [linux_crypto_nitrokey_interface_0, '0', epy_block_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
