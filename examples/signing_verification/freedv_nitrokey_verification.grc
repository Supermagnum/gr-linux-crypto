options:
  parameters:
    author: gr-linux-crypto
    category: '[gr-linux-crypto]/Examples'
    copyright: Copyright 2024
    description: FreeDV voice signature verification using gr-nacl Ed25519. Verifies signatures embedded in FreeDV Codec2 frames after demodulation.
    generate_options: qt_gui
    id: freedv_nitrokey_verification
    output_language: python
    title: FreeDV Verification with Nitrokey
  states: {}

blocks:
- name: nitrokey_slot
  id: variable_qtgui_entry
  parameters:
    comment: Nitrokey slot number (0-15) containing Ed25519 public key
    gui_hint: 1,0,1,1
    label: Nitrokey Slot
    type: int
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Sample rate for audio processing
    value: '8000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: Audio output for verified voice
    samp_rate: '48000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: Load signed FreeDV signal from file (replace with radio hardware for RX)
    file: /tmp/freedv_signed_transmission.bin
    repeat: 'False'
    type: short
  states: {}
- name: blocks_short_to_char_0
  id: blocks_short_to_char
  parameters:
    comment: Convert short to bytes for verification
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    comment: Convert short audio to float
    scale: '32768'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      try:
          from gnuradio import nacl
          NACL_AVAILABLE = True
      except ImportError:
          NACL_AVAILABLE = False
          print("Warning: gr-nacl not available. Verification will not work.")

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='FreeDV Voice Verifier',
                  in_sig=[np.uint8, np.uint8],
                  out_sig=[np.uint8]
              )
              self._signed_buffer = bytearray()
              self._key_buffer = bytearray()
              self._signature_length = 64  # Ed25519 signature is 64 bytes
              self._frame_size_with_signature = 8 + 64  # Codec2 frame (8) + signature (64) = 72 bytes
              
          def work(self, input_items, output_items):
              signed_in = input_items[0]
              key_in = input_items[1]
              
              # Collect signed Codec2 data
              if len(signed_in) > 0:
                  self._signed_buffer.extend(signed_in.tolist())
              
              # Collect key data from Nitrokey (need 32 bytes for Ed25519)
              if len(key_in) > 0:
                  self._key_buffer.extend(key_in.tolist())
              
              out_len = min(len(output_items[0]), len(signed_in))
              
              # Verify when we have complete signed frame
              if len(self._signed_buffer) >= self._frame_size_with_signature and len(self._key_buffer) >= 32:
                  try:
                      # Get signed frame (8 bytes Codec2 + 64 bytes signature)
                      signed_frame = bytes(self._signed_buffer[:self._frame_size_with_signature])
                      self._signed_buffer = self._signed_buffer[self._frame_size_with_signature:]
                      
                      # Extract Codec2 frame and signature
                      codec2_frame = signed_frame[:8]
                      signature = signed_frame[8:]
                       
                      # Get public key (32 bytes for Ed25519)
                      public_key = bytes(self._key_buffer[:32])
                      
                      if NACL_AVAILABLE and len(public_key) == 32 and len(signature) == 64:
                          # Verify Ed25519 signature using gr-nacl
                          try:
                              is_valid = nacl.verify_ed25519(codec2_frame, signature, public_key)
                               if is_valid:
                                  # Output verified Codec2 frame
                                  out_data = np.frombuffer(codec2_frame[:out_len], dtype=np.uint8)
                                  if len(out_data) <= len(output_items[0]):
                                      output_items[0][:len(out_data)] = out_data
                                       return len(out_data)
                              else:
                                  print(f"FAILED: FreeDV Codec2 frame signature is INVALID")
                                  # Output silent frame on verification failure
                                  silent_frame = b'\x00' * 8
                                  out_data = np.frombuffer(silent_frame[:out_len], dtype=np.uint8)
                                  if len(out_data) <= len(output_items[0]):
                                      output_items[0][:len(out_data)] = out_data
                                       return len(out_data)
                          except AttributeError:
                              print("Warning: gr-nacl verify_ed25519 not found. Cannot verify.")
                              # Pass through without verification
                              out_data = np.frombuffer(codec2_frame[:out_len], dtype=np.uint8)
                              if len(out_data) <= len(output_items[0]):
                                  output_items[0][:len(out_data)] = out_data
                                   return len(out_data)
                      else:
                          print("Warning: Verification not available - missing key or signature")
                          # Pass through without verification
                          out_data = np.frombuffer(codec2_frame[:out_len], dtype=np.uint8)
                          if len(out_data) <= len(output_items[0]):
                              output_items[0][:len(out_data)] = out_data
                               return len(out_data)
                  except Exception as e:
                      print(f"Verification error: {e}")
                      import traceback
                      traceback.print_exc()
                      # Output silent frame on error
                      silent_frame = b'\x00' * 8
                      out_data = np.frombuffer(silent_frame[:out_len], dtype=np.uint8)
                      if len(out_data) <= len(output_items[0]):
                          output_items[0][:len(out_data)] = out_data
                          return len(out_data)
              
              # No data to output yet
              return 0
  states: {}
- name: linux_crypto_nitrokey_interface_0
  id: linux_crypto_nitrokey_interface
  parameters:
    auto_repeat: 'False'
    comment: Load Ed25519 public key from Nitrokey slot for verification
    slot: nitrokey_slot
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: Resample audio from 8kHz to 48kHz
    decim: '1'
    interp: '6'
    taps: ''
    type: fff
  states: {}
- name: vocoder_codec2_decode_ps_0
  id: vocoder_codec2_decode_ps
  parameters:
    comment: Codec2 decoder - decompresses verified voice bits
    mode: codec2.MODE_2400
  states: {}
- name: vocoder_freedv_rx_ss_0
  id: vocoder_freedv_rx_ss
  parameters:
    comment: FreeDV demodulator - receives signed voice
    interleave_frames: '1'
    mode: freedv_api.MODE_1600
    squelch_enable: 'True'
    squelch_thresh: '-100.0'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_short_to_char_0, '0', epy_block_0, '0']
- [blocks_short_to_float_0, '0', rational_resampler_xxx_0, '0']
- [blocks_throttle2_0, '0', vocoder_freedv_rx_ss_0, '0']
- [epy_block_0, '0', vocoder_codec2_decode_ps_0, '0']
- [linux_crypto_nitrokey_interface_0, '0', epy_block_0, '1']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [vocoder_codec2_decode_ps_0, '0', blocks_short_to_float_0, '0']
- [vocoder_freedv_rx_ss_0, '0', blocks_short_to_char_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
