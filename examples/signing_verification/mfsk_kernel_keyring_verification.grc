options:
  parameters:
    author: gr-linux-crypto
    category: '[gr-linux-crypto]/Examples'
    copyright: Copyright 2024
    description: MFSK message signature verification using gr-nacl Ed25519. Verifies signatures embedded in MFSK messages using public keys from Linux kernel keyring.
    generate_options: qt_gui
    id: mfsk_kernel_keyring_verification
    output_language: python
    title: MFSK Signature Verification (Kernel Keyring)
  states: {}

blocks:
- name: key_id
  id: variable_qtgui_entry
  parameters:
    comment: Linux kernel keyring key ID containing Ed25519 public key
    gui_hint: 1,0,1,1
    label: Kernel Keyring Key ID
    type: int
    value: '0'
  states: {}
- name: public_key_file
  id: variable_qtgui_entry
  parameters:
    comment: Path to Ed25519 public key file (PEM format) - optional if using kernel keyring
    gui_hint: 3,0,1,1
    label: Public Key File (optional)
    type: string
    value: ''
  states: {}
- name: signed_message_file
  id: variable_qtgui_entry
  parameters:
    comment: Path to file containing signed MFSK message
    gui_hint: 2,0,1,1
    label: Signed Message File
    type: string
    value: /tmp/mfsk_signed_transmission.bin
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: Load signed MFSK message from file
    file: signed_message_file
    repeat: 'False'
    type: byte
  states: {}
- name: linux_crypto_kernel_keyring_source_0
  id: linux_crypto_kernel_keyring_source
  parameters:
    auto_repeat: 'False'
    comment: Load Ed25519 public key from Linux kernel keyring
    key_id: key_id
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import os
      try:
          from gnuradio import nacl
          NACL_AVAILABLE = True
      except ImportError:
          NACL_AVAILABLE = False
          print("Warning: gr-nacl not available. Verification will not work.")

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='MFSK Signature Verifier (Kernel Keyring)',
                  in_sig=[np.uint8, np.uint8],
                  out_sig=[np.uint8]
              )
              self._signed_message_buffer = bytearray()
              self._key_buffer = bytearray()
              self._signature_length = 64  # Ed25519 signature is 64 bytes
              self._verified = False
              self._verification_status = None
              self._original_message = None
              
          def work(self, input_items, output_items):
              msg_in = input_items[0]
              key_in = input_items[1]
              
              # Collect signed message data
              if len(msg_in) > 0:
                  self._signed_message_buffer.extend(msg_in.tolist())
              
              # Collect key data from kernel keyring
              if len(key_in) > 0:
                  self._key_buffer.extend(key_in.tolist())
              
              out_len = min(len(output_items[0]), len(msg_in))
              
              # If we have enough data, verify signature
              if not self._verified and len(self._signed_message_buffer) >= self._signature_length and len(self._key_buffer) >= 32:
                  try:
                      signed_data = bytes(self._signed_message_buffer)
                       
                      # Extract message and signature
                      if len(signed_data) >= self._signature_length:
                          message = signed_data[:-self._signature_length]
                          signature = signed_data[-self._signature_length:]
                           
                          # Get public key (32 bytes for Ed25519)
                           public_key = bytes(self._key_buffer[:32])
                          
                           if NACL_AVAILABLE and len(public_key) == 32 and len(signature) == 64:
                              # Verify Ed25519 signature using gr-nacl
                               try:
                                  # Note: Adjust gr-nacl API call based on actual module API
                                  is_valid = nacl.verify_ed25519(message, signature, public_key)
                                  self._verification_status = is_valid
                                  self._original_message = message
                                   self._verified = True
                                  
                                   if is_valid:
                                      print(f"VERIFIED: MFSK message signature is VALID (kernel keyring)")
                                      print(f"Message length: {len(message)} bytes")
                                      print(f"Message: {message.decode('utf-8', errors='ignore')}")
                                  else:
                                       print(f"FAILED: MFSK message signature is INVALID")
                                       print(f"Message may have been tampered with or signed with different key")
                              except AttributeError:
                                  # Fallback if API is different
                                  print("Warning: gr-nacl verify_ed25519 not found. Cannot verify.")
                                  self._verification_status = None
                                  self._original_message = message
                                   self._verified = True
                          else:
                              print("Warning: Verification not available - missing key or signature")
                               self._original_message = message
                              self._verified = True
                  except Exception as e:
                      print(f"Verification error: {e}")
                      import traceback
                      traceback.print_exc()
                      self._verified = True
              
              # Output original message (without signature)
              if self._verified and self._original_message:
                  if len(self._original_message) > 0:
                      out_data = np.frombuffer(self._original_message[:out_len], dtype=np.uint8)
                      if len(out_data) <= len(output_items[0]):
                          output_items[0][:len(out_data)] = out_data
                           # Remove sent data from buffer
                          self._original_message = self._original_message[len(out_data):]
                          return len(out_data)
              
              # No data to output yet
              return 0
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Sample rate for processing
    value: '48000'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: Visualize verified MFSK message data
    label1: Verified MFSK Message
    label2: ''
    name: '"Verified MFSK Message"'
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '127'
    ymin: '-128'
  states: {}

connections:
- [blocks_file_source_0, '0', epy_block_0, '0']
- [epy_block_0, '0', blocks_throttle2_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']
- [linux_crypto_kernel_keyring_source_0, '0', epy_block_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
